# IAR project Project.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: STM32F429BI ST STM32F429BI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp\inc; ..\..\User\bsp; ..\..\User; ..\..\uCOS-III\uC-CPU; ..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOS-III\uC-LIB; ..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\uCOS-III\uCOS-III\Source; ..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\User\fonts; ..\..\emWin\Include; ..\..\emWin\emWinTaskIAR; ..\..\emWin\Config; ..\..\User\FatFS\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_assert.c stm32f4xx_it.c
    ../../User/bsp/src/: bsp_eeprom_24xx.c bsp_ext_io.c bsp_fmc_sdram.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_sdio_sd.c bsp_tim_pwm.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.例程操作说明.txt
  group EWARMv7
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group FatFS
    ../../User/FatFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/DEMO
    ../../emWin/emWinTaskIAR/: App_ScaleWin.c App_SysFunction.c MainTask.c MainTask.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_IAR_ot.a
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group LCD_Driver
    ../../User/bsp/src/: bsp_gt811.c bsp_tft_429.c bsp_tft_lcd.c bsp_touch.c bsp_ts_ft5x06.c param.c TOUCH_STMPE811.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group User
    ../../User/: app_cfg.h cpu_bsp.c cpu_cfg.h includes.h lib_cfg.h main.c os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
