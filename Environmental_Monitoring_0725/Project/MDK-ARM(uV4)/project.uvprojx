# Keil uVision project project.uvprojx, settings and files
target STM32F429 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__CC_ARM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\PNG;..\..\User\font;..\..\User\AnimUIDemo\ALDES;..\..\User\wifi;..\..\User\cjson;..\..\User\cjson\MALLOC;..\..\User\Azure\azure_c_shared_utility;..\..\User\bsp\inc;..\..\User\sensor_sample;..\..\User\CGK;..\..\User\RTC;..\..\User\usb_cdc_device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h cpu_bsp.c os_cfg_app.h os_app_hooks.c os_app_hooks.h
    ../../User/sensor_sample/: sensor_measure.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ../../User/bsp/src/: bsp_uart_fifo.c bsp_tim_pwm.c ringbuffer.c tty.c bsp_i2c_gpio.c bsp_touch.c bsp_ts_ft5x06.c bsp_spi_bus.c bsp_spi_flash.c bsp_fmc_sdram.c touch_key.c bsp_ts_gt911.c
    ../../User/sensor_sample/: bsp_adc.c HT1080.c I2C_simulation.c spi.c
    ../../User/wifi/: HFLPT230.c
    ../../User/RTC/: tm_stm32f4_rtc.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_dma2d.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/Config
    ../../emWin/Config_disco/: GUIConf.c
    ../../emWin/Config/: GUIDRV_stm32f429i_discovery.c
  group GUI/DEMO
    ../../User/AnimUIDemo/: MOTION_SmartPhoneMenu.c iconview.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib STemWin522_4x9i_CM4_OS_Keil.lib STemWin540_CM4_OS_Keil_ot_ARGB.lib
  group cjson
    ../../User/cjson/: cJSON.c cJSON_APP.c
  group font
    ../../User/font/: HoloLens MDL2 Assets27.c PingFang_Regular33.c PingFang_Regular41.c PingFang_Regular38.c Dingbats2114.c PingFang_Regular45.c PingFang_Regular67.c
  group azure
    ../../User/Azure/src/: hmac.c sha1.c sha224.c sha384-512.c usha.c base64.c buffer.c strings.c
    ../../User/cjson/MALLOC/: malloc.c
  group CGK
    ../../User/CGK/: bsp_i2c_cgk.c Cgk_module.c
  group Doc
    ../../Doc/: 02.例程修改记录.txt
software components: CMSIS:CORE 4.3.0
